# Keil uVision project swm320_pikascript.uvprojx, settings and files
target SWM320 (6180000::V6.18::ARMCLANG)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.20.12
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: firmware
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: LV_LVGL_H_INCLUDE_SIMPLE,LV_EX_CONF_INCLUDE_SIMPLE,PIKA_CONFIG_ENABLE,PIKASCRIPT
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM320_StdPeriph_Driver;.\APP;.\APP\lvgl;.\APP\lvgl\src;.\APP\lvgl\src\lv_core;.\APP\lvgl\src\lv_draw;.\APP\lvgl\src\lv_font;.\APP\lvgl\src\lv_hal;.\APP\lvgl\src\lv_misc;.\APP\lvgl\src\lv_objx;.\APP\lvgl\src\lv_themes;.\APP\bsp;.\FATFS;.\sfud\inc;.\sfud\port;.\sfud\src;.\APP\lv_port;.\APP\lvgl\src\lv_gpu;.\APP\lvgl\demos\widgets;.\APP\pikascript\pikascript-core;.\APP\pikascript\pikascript-api;..\..\include;..\..\engines\pikascript
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\SWM320_stdperiph_lib.sct
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM320_StdPeriph_Driver/: SWM320_port.c SWM320_gpio.c SWM320_exti.c SWM320_timr.c SWM320_uart.c SWM320_adc.c SWM320_dma.c SWM320_i2c.c SWM320_pwm.c SWM320_can.c SWM320_spi.c SWM320_sdio.c SWM320_lcd.c SWM320_flash.c SWM320_crc.c SWM320_rtc.c SWM320_wdt.c SWM320_norflash.c SWM320_sdram.c SWM320_sram.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
  group bsp
    ./APP/bsp/: dev_rgblcd.c dev_systick.c dev_uart.c dev_sdio.c dev_gt911.c
  group sfud
    ./sfud/port/: sfud_port.c
    ./sfud/src/: sfud.c sfud_sfdp.c
  group FATFS
    ./FATFS/: diskio.c ff.c ffunicode.c
  group lvgl_port
    ./APP/lv_port/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lvgl
    ./APP/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./APP/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./APP/lvgl/src/extra/: lv_extra.c
    ./APP/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./APP/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./APP/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./APP/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c lv_canvas.c
    ./APP/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./APP/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./APP/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./APP/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./APP/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./APP/lvgl/src/extra/widgets/menu/: lv_menu.c
    ./APP/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./APP/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./APP/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./APP/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./APP/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./APP/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./APP/lvgl/src/extra/widgets/led/: lv_led.c
    ./APP/lvgl/src/extra/widgets/list/: lv_list.c
    ./APP/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./APP/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./APP/lvgl/src/extra/widgets/span/: lv_span.c
    ./APP/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./APP/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./APP/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./APP/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./APP/lvgl/src/extra/widgets/win/: lv_win.c
    ./APP/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./APP/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./APP/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./APP/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./APP/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./APP/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ./APP/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ./APP/lvgl/src/extra/others/monkey/: lv_monkey.c
    ./APP/lvgl/src/extra/others/msg/: lv_msg.c
    ./APP/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./APP/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./APP/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
  group pikascript-core
    ./APP/pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaCompiler.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group pikascript-api
    ./APP/pikascript/pikascript-api/: __asset_pikaModules_py_a.c __pikaBinding.c pikaScript.c
  group pikascript-lib
    ./APP/pikascript/pikascript-lib/PikaStdLib/: PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_Dict.c PikaStdData_FILEIO.c PikaStdData_List.c PikaStdData_String.c PikaStdData_Tuple.c PikaStdData_Utils.c PikaStdLib_MemChecker.c PikaStdLib_RangeObj.c PikaStdLib_StringObj.c PikaStdLib_SysObj.c PikaStdTask_Task.c
    ./APP/pikascript/pikascript-lib/PikaStdDevice/: PikaStdDevice_ADC.c PikaStdDevice_BaseDev.c PikaStdDevice_CAN.c PikaStdDevice_GPIO.c PikaStdDevice_IIC.c PikaStdDevice_PWM.c PikaStdDevice_SPI.c PikaStdDevice_Time.c PikaStdDevice_UART.c
    ./APP/pikascript/pikascript-lib/pika_lvgl/: pika_lv_point_t.c pika_lv_timer_t.c pika_lv_wegit.c pika_lvgl.c pika_lvgl_indev_t.c pika_lvgl_lv_event.c pika_lvgl_lv_obj.c pika_lvgl_lv_style_t.c
  group Python
    ./APP/pikascript/: main.py pika_lvgl.pyi requestment.txt before-build.bat
  group evm
    ../../engines/pikascript/: evm.c
