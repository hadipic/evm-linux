# Keil uVision project pikascript.uvprojx, settings and files
target STM32L4R9I-Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x000A0000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: HAL_UART_MODULE_ENABLED,LV_CONF_INCLUDE_SIMPLE,LV_LVGL_H_INCLUDE_SIMPLE,LV_EX_CONF_INCLUDE_SIMPLE,PIKA_CONFIG_ENABLE,PIKASCRIPT
  c include: ..\Inc;..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\Drivers\BSP\STM32L4R9I-Discovery;..\..\Middlewares\Third_Party\FatFs\src;..\..\Drivers\BSP\Components\mfxstm32l152;..\..\..\..\components\lvgl\lvgl;..\..\..\..\include;..\..\..\..\engines\pikascript;..\..\pikascript;..\..\pikascript\pikascript-core;..\..\pikascript\pikascript-api;..\..\lv_port;..\..\..\..\components\lvgl\lvgl\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Drivers/BSP/STM32L4R9I-Discovery
    ../../Drivers/BSP/STM32L4R9I-Discovery/: stm32l4r9i_discovery_io.c stm32l4r9i_discovery.c stm32l4r9i_discovery_sd.c stm32l4r9i_discovery_psram.c stm32l4r9i_discovery_ts.c
    ../Inc/: stm32l4xx_hal_conf.h
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sram.c stm32l4xx_ll_fmc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../Drivers/BSP/Components/ft3x67/: ft3x67.c
  group Example/User
    ../Src/: stm32l4xx_it.c main.c stm32l4xx_hal_msp.c sd_diskio.c lv_conf.h
  group Example/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l4r9xx.s
  group Middlewares/FatFs/core
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/options
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group lvgl
    ../../../../components/lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../../../components/lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../../components/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../../../components/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../../../components/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../../../components/lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../../../components/lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../../components/lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../../components/lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../../../components/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../../../components/lvgl/lvgl/src/extra/: lv_extra.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/led/: lv_led.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/span/: lv_span.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../../../components/lvgl/lvgl/src/extra/widgets/win/: lv_win.c
    ../../../../components/lvgl/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
  group lv_port
    ../../lv_port/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group pikascript-core
    ../../pikascript/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaCompiler.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group pikascript-api
    ../../pikascript/pikascript-api/: __asset_pikaModules_py_a.c __pikaBinding.c
  group pikascript-lib
    ../../pikascript/pikascript-lib/pika_lvgl/: pika_lv_point_t.c pika_lv_timer_t.c pika_lv_wegit.c pika_lvgl.c pika_lvgl_indev_t.c pika_lvgl_lv_event.c pika_lvgl_lv_obj.c pika_lvgl_lv_style_t.c
    ../../pikascript/pikascript-lib/PikaStdLib/: PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_Dict.c PikaStdData_FILEIO.c PikaStdData_List.c PikaStdData_String.c PikaStdData_Tuple.c PikaStdData_Utils.c PikaStdLib_MemChecker.c PikaStdLib_RangeObj.c PikaStdLib_StringObj.c PikaStdLib_SysObj.c PikaStdTask_Task.c
  group evm
    ../../../../engines/pikascript/: evm.c
software components: CMSIS:CORE 5.6.0
