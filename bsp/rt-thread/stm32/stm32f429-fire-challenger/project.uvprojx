# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, CONFIG_EVM_MODULE_UART, USE_HAL_DRIVER, RT_USING_LIBC, CONFIG_EVM_MODULE_GPIO, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARM_LIBC, STM32F429xx
  c include: applications;.;..\..\..\..\..\rt-thread\components\libc\compilers\common\include;..\..\..\..\..\rt-thread\components\libc\compilers\common\extension;..\..\..\..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\rt-thread\libcpu\arm\common;..\..\..\..\..\rt-thread\libcpu\arm\cortex-m4;..\..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\..\rt-thread\components\drivers\include;..\..\..\..\..\rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\..\..\..\..\rt-thread\bsp\stm32\libraries\HAL_Drivers;..\..\..\..\..\rt-thread\bsp\stm32\libraries\HAL_Drivers\config;..\..\..\..\..\rt-thread\bsp\stm32\libraries\HAL_Drivers\CMSIS\Include;..\..\..\..\engines\mujs;..\..\..\..\engines\mujs\mujs;..\..\..\..\include;..\..\..\..\..\rt-thread\components\dfs\include;..\..\..\..\..\rt-thread\components\dfs\filesystems\elmfat;..\..\..\..\..\rt-thread\components\finsh;.;..\..\..\..\..\rt-thread\include;..\..\..\..\..\rt-thread\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\rt-thread\bsp\stm32\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\modules\iotjs\rt-thread;..\..\..\..\modules\iotjs\common;..\..\..\..\..\rt-thread\components\libc\posix\io\poll;..\..\..\..\..\rt-thread\components\libc\posix\io\stdio;..\..\..\..\..\rt-thread\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../../../rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../rt-thread/components/drivers/misc/: pin.c
    ../../../../../rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    ../../../../../rt-thread/bsp/stm32/libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    ../../../../../rt-thread/bsp/stm32/libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
  group engines
    ../../../../engines/mujs/mujs/: one.c
    ../../../../engines/mujs/: evm.c
  group Filesystem
    ../../../../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../../rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../../../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../../../../../rt-thread/bsp/stm32/libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c
    ../../../../../rt-thread/bsp/stm32/libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group modules
    ../../../../modules/iotjs/rt-thread/: evm_main.c rtt_module_adc.c rtt_module_gpio.c rtt_module_i2c.c rtt_module_timers.c rtt_module_uart.c
    ../../../../modules/iotjs/common/: evm_module.c evm_module_adc.c evm_module_assert.c evm_module_buffer.c evm_module_cffi.c evm_module_dns.c evm_module_events.c evm_module_fs.c evm_module_gpio.c evm_module_i2c.c evm_module_libc.c evm_module_network.c evm_module_process.c evm_module_timers.c evm_module_uart.c
